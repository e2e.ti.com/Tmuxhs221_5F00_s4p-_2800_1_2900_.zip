!Agilent Technologies,N5225A,MY51451112,A.09.50.13
!Agilent N5225A: A.09.50.13
!Date: Friday, October 01, 2021 10:44:03
!Correction: Sdd11(Full 4 Port(1,2,3,4))
!Sdc11(Full 4 Port(1,2,3,4))
!Sdd12(Full 4 Port(1,2,3,4))
!Sdc12(Full 4 Port(1,2,3,4))
!Scd11(Full 4 Port(1,2,3,4))
!Scc11(Full 4 Port(1,2,3,4))
!Scd12(Full 4 Port(1,2,3,4))
!Scc12(Full 4 Port(1,2,3,4))
!Sdd21(Full 4 Port(1,2,3,4))
!Sdc21(Full 4 Port(1,2,3,4))
!Sdd22(Full 4 Port(1,2,3,4))
!Sdc22(Full 4 Port(1,2,3,4))
!Scd21(Full 4 Port(1,2,3,4))
!Scc21(Full 4 Port(1,2,3,4))
!Scd22(Full 4 Port(1,2,3,4))
!Scc22(Full 4 Port(1,2,3,4))
!Balanced Topology: BBAL
!S4P File: Measurements: <Sdd11,Sdc11,Sdd12,Sdc12>,
!<Scd11,Scc11,Scd12,Scc12>,
!<Sdd21,Sdc21,Sdd22,Sdc22>,
!<Scd21,Scc21,Scd22,Scc22>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   801 points, 10 MHz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 10.01 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S21: -44.1, -23.7, -17.9, -13.8, -18.2
!     S43: -44.3, -25.6, -16.4, -6.7, -22.3
!     S42: -52.0, -15.1, -24.4, -27.4, -36.0
!     S31: -59.3, -19.7, -25.4, -29.7, -45.7
!     S41: -60.9, -33.6, -35.8, -28.0, -41.0
!     S32: -58.8, -53.0, -40.8, -29.0, -45.8
!   lowest |S11| = -36.5 dB at 10 MHz (marker M1), VSWR 1.03, Z = 50.1 + j1.49 ohm
!   |S11| at or under -10 dB: start of sweep to 6.722 GHz; 7.228 GHz to 10.41 GHz (3.181 GHz wide, 36.1 % of centre); 36.53 GHz to 37.44 GHz (910.6 MHz wide, 2.46 % of centre) (the widest 3 of 9)
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! magnitudes (dB):
! f  S11  S21  S43  S42  S31  S41  S32
! 10 MHz  -36.5  -44.1  -44.3  -52.0  -59.3  -60.9  -58.8
! 6.208 GHz  -17.0  -29.5  -27.4  -11.3  -21.1  -31.7  -45.0
! 26.2 GHz  -0.5  -20.9  -26.7  -36.3  -44.9  -42.7  -35.9
! 33.7 GHz  -3.8  -4.2  -9.4  -30.0  -18.7  -33.5  -25.2
! 36.75 GHz  -14.3  -36.1  -39.0  -71.2  -74.0  -75.9  -71.8
! 38.65 GHz  6.7  -2.2  -30.0  -42.6  -31.3  -36.9  -39.6
! 40 GHz  -8.6  -18.2  -22.3  -36.0  -45.7  -41.0  -45.8
