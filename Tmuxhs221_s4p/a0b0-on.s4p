!Agilent Technologies,N5225A,MY51451112,A.09.50.13
!Agilent N5225A: A.09.50.13
!Date: Friday, October 01, 2021 10:36:48
!Correction: Sdd11(Full 4 Port(1,2,3,4))
!Sdc11(Full 4 Port(1,2,3,4))
!Sdd12(Full 4 Port(1,2,3,4))
!Sdc12(Full 4 Port(1,2,3,4))
!Scd11(Full 4 Port(1,2,3,4))
!Scc11(Full 4 Port(1,2,3,4))
!Scd12(Full 4 Port(1,2,3,4))
!Scc12(Full 4 Port(1,2,3,4))
!Sdd21(Full 4 Port(1,2,3,4))
!Sdc21(Full 4 Port(1,2,3,4))
!Sdd22(Full 4 Port(1,2,3,4))
!Sdc22(Full 4 Port(1,2,3,4))
!Scd21(Full 4 Port(1,2,3,4))
!Scc21(Full 4 Port(1,2,3,4))
!Scd22(Full 4 Port(1,2,3,4))
!Scc22(Full 4 Port(1,2,3,4))
!Balanced Topology: BBAL
!S4P File: Measurements: <Sdd11,Sdc11,Sdd12,Sdc12>,
!<Scd11,Scc11,Scd12,Scc12>,
!<Sdd21,Sdc21,Sdd22,Sdc22>,
!<Scd21,Scc21,Scd22,Scc22>:
# Hz S  dB  R 50
! Worked out from all points (differential pair):
!   801 points, 10 MHz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 10.01 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S31: -0.4, -2.6, -9.1, -10.1, -50.7
!     S42: -0.4, -7.2, -14.0, -14.5, -36.8
!     S21: -46.6, -22.7, -20.9, -7.7, -14.0
!     S43: -45.2, -21.7, -24.0, -8.8, -28.8
!     S32: -62.2, -23.1, -26.5, -17.4, -57.3
!     S41: -53.7, -24.5, -30.7, -18.2, -39.8
!   taken as a pair (ports 1,2 in; 3,4 out), SDD21 dB: -0.4, -4.1, -10.3, -17.0, -37.9
!   lowest |S11| = -29.0 dB at 259.9 MHz (marker M1), VSWR 1.07, Z = 53.5 - j1.04 ohm
!   |S11| at or under -10 dB: start of sweep to 7.645 GHz; 8.732 GHz to 10.16 GHz (1.424 GHz wide, 15.1 % of centre); 36.53 GHz to 37.44 GHz (907.2 MHz wide, 2.45 % of centre) (the widest 3 of 7)
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! magnitudes (dB):
! f  S11  S31  S42  S21  S43  S32  S41
! 10 MHz  -28.5  -0.4  -0.4  -46.6  -45.2  -62.2  -53.7
! 259.9 MHz  -29.0  -0.5  -0.5  -47.8  -46.1  -50.0  -49.8
! 26.6 GHz  3.8  -17.6  -43.4  -15.0  -27.9  -25.7  -31.6
! 30.95 GHz  -2.1  -10.3  -15.6  -5.3  -9.8  -15.1  -18.8
! 34 GHz  1.7  -19.1  -15.6  -1.5  -3.1  -15.5  -22.2
! 36.65 GHz  -11.6  -63.3  -68.2  -37.9  -44.9  -65.2  -66.8
! 40 GHz  -8.8  -50.7  -36.8  -14.0  -28.8  -57.3  -39.8
