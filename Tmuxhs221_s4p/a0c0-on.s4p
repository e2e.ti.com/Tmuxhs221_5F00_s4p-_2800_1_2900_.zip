!Agilent Technologies,N5225A,MY51451112,A.09.50.13
!Agilent N5225A: A.09.50.13
!Date: Friday, October 01, 2021 10:43:00
!Correction: Sdd11(Full 4 Port(1,2,3,4))
!Sdc11(Full 4 Port(1,2,3,4))
!Sdd12(Full 4 Port(1,2,3,4))
!Sdc12(Full 4 Port(1,2,3,4))
!Scd11(Full 4 Port(1,2,3,4))
!Scc11(Full 4 Port(1,2,3,4))
!Scd12(Full 4 Port(1,2,3,4))
!Scc12(Full 4 Port(1,2,3,4))
!Sdd21(Full 4 Port(1,2,3,4))
!Sdc21(Full 4 Port(1,2,3,4))
!Sdd22(Full 4 Port(1,2,3,4))
!Sdc22(Full 4 Port(1,2,3,4))
!Scd21(Full 4 Port(1,2,3,4))
!Scc21(Full 4 Port(1,2,3,4))
!Scd22(Full 4 Port(1,2,3,4))
!Scc22(Full 4 Port(1,2,3,4))
!Balanced Topology: BBAL
!S4P File: Measurements: <Sdd11,Sdc11,Sdd12,Sdc12>,
!<Scd11,Scc11,Scd12,Scc12>,
!<Sdd21,Sdc21,Sdd22,Sdc22>,
!<Scd21,Scc21,Scd22,Scc22>:
# Hz S  dB  R 50
! Worked out from all points (differential pair):
!   801 points, 10 MHz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 10.01 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S31: -0.4, -4.6, -10.7, -11.2, -43.3
!     S42: -0.4, -7.8, -16.0, -27.8, -37.8
!     S43: -47.8, -23.4, -15.7, -7.4, -24.2
!     S21: -46.8, -20.4, -19.1, -15.2, -18.1
!     S32: -47.9, -19.7, -41.3, -28.1, -42.7
!     S41: -46.7, -19.8, -33.3, -21.9, -44.3
!   taken as a pair (ports 1,2 in; 3,4 out), SDD21 dB: -0.4, -4.8, -12.8, -14.4, -40.0
!   lowest |S11| = -28.7 dB at 59.99 MHz (marker M1), VSWR 1.08, Z = 51.3 + j3.5 ohm
!   |S11| at or under -10 dB: start of sweep to 7.655 GHz; 8.09 GHz to 10.77 GHz (2.684 GHz wide, 28.5 % of centre); 11.99 GHz to 14.64 GHz (2.651 GHz wide, 19.9 % of centre) (the widest 3 of 6)
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! magnitudes (dB):
! f  S11  S31  S42  S43  S21  S32  S41
! 10 MHz  -28.6  -0.4  -0.4  -47.8  -46.8  -47.9  -46.7
! 59.99 MHz  -28.7  -0.5  -0.5  -47.9  -47.4  -47.4  -46.5
! 26.2 GHz  -0.5  -44.1  -38.2  -26.9  -21.9  -39.0  -42.8
! 32.45 GHz  -2.8  -13.6  -25.4  -13.2  -8.4  -33.3  -33.3
! 34.6 GHz  1.0  -24.0  -30.4  -9.2  -12.8  -26.7  -31.3
! 36.55 GHz  -10.2  -76.3  -79.5  -43.5  -38.8  -76.7  -82.2
! 40 GHz  -8.8  -43.3  -37.8  -24.2  -18.1  -42.7  -44.3
