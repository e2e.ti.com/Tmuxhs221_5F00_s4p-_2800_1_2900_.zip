!Agilent Technologies,N5225A,MY51451112,A.09.50.13
!Agilent N5225A: A.09.50.13
!Date: Friday, October 01, 2021 10:46:15
!Correction: Sdd11(Full 4 Port(1,2,3,4))
!Sdc11(Full 4 Port(1,2,3,4))
!Sdd12(Full 4 Port(1,2,3,4))
!Sdc12(Full 4 Port(1,2,3,4))
!Scd11(Full 4 Port(1,2,3,4))
!Scc11(Full 4 Port(1,2,3,4))
!Scd12(Full 4 Port(1,2,3,4))
!Scc12(Full 4 Port(1,2,3,4))
!Sdd21(Full 4 Port(1,2,3,4))
!Sdc21(Full 4 Port(1,2,3,4))
!Sdd22(Full 4 Port(1,2,3,4))
!Sdc22(Full 4 Port(1,2,3,4))
!Scd21(Full 4 Port(1,2,3,4))
!Scc21(Full 4 Port(1,2,3,4))
!Scd22(Full 4 Port(1,2,3,4))
!Scc22(Full 4 Port(1,2,3,4))
!Balanced Topology: BBAL
!S4P File: Measurements: <Sdd11,Sdc11,Sdd12,Sdc12>,
!<Scd11,Scc11,Scd12,Scc12>,
!<Sdd21,Sdc21,Sdd22,Sdc22>,
!<Scd21,Scc21,Scd22,Scc22>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   801 points, 10 MHz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 10.01 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S43: -44.7, -12.9, -23.1, -9.5, -22.9
!     S21: -43.3, -22.2, -21.5, -10.9, -14.9
!     S42: -49.7, -17.0, -23.0, -15.3, -34.0
!     S31: -54.0, -19.9, -25.4, -26.8, -45.3
!     S32: -66.2, -28.0, -38.8, -28.3, -43.5
!     S41: -58.3, -49.8, -35.5, -23.2, -37.0
!   lowest |S11| = -35.2 dB at 10 MHz (marker M1), VSWR 1.04, Z = 49.9 + j1.73 ohm
!   |S11| at or under -10 dB: start of sweep to 4.454 GHz; 4.514 GHz to 6.762 GHz (2.248 GHz wide, 39.9 % of centre); 8.388 GHz to 10.31 GHz (1.922 GHz wide, 20.6 % of centre) (the widest 3 of 12)
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! magnitudes (dB):
! f  S11  S43  S21  S42  S31  S32  S41
! 10 MHz  -35.2  -44.7  -43.3  -49.7  -54.0  -66.2  -58.3
! 5.109 GHz  -13.7  -18.1  -18.1  -12.8  -21.3  -36.6  -32.8
! 25.6 GHz  -2.7  0.5  -17.7  -23.2  -16.2  -20.1  -21.5
! 26.6 GHz  2.9  -24.6  -17.6  -40.1  -18.1  -26.2  -28.8
! 33.35 GHz  -2.0  -12.6  -3.3  -15.2  -24.5  -28.0  -23.8
! 36.65 GHz  -11.5  -44.0  -39.0  -67.5  -66.3  -64.9  -68.6
! 40 GHz  -9.0  -22.9  -14.9  -34.0  -45.3  -43.5  -37.0
